# Keil uVision project peripherals_app.uvprojx, settings and files
target peripherals_app (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: peripherals_app +hex
  AfterMake: E:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin  -o  app.bin .\Objects\peripherals_app.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\APP;..\CORE;..\PERIPHERALS\Includes;..\SYSTEM;..\USER;..\PERIPHERALS\Sources;..\PROJECT
  memory RVCT4: ROM 0x400 size 0xfc00
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CORE
    ../CORE/: core_cm3.c
  group STARTUP
    ../STARTUP/: startup_GOWIN_M3.s
  group SYSTEM
    ../SYSTEM/: system_GOWIN_M3.c
  group PERIPHERALS
    ../PERIPHERALS/Sources/: GOWIN_M3_ddr3.c GOWIN_M3_ethernet.c GOWIN_M3_gpio.c GOWIN_M3_i2c.c GOWIN_M3_misc.c GOWIN_M3_rtc.c GOWIN_M3_spi.c GOWIN_M3_spi_flash.c GOWIN_M3_timer.c GOWIN_M3_uart.c GOWIN_M3_wdog.c
  group APP
    ../APP/: app.c
    ./: cmd_line.c cmd_line.h
  group USER
    ../USER/: main.c app_if.c GOWIN_M3_it.c malloc.c retarget.c
